! MARKI MICROWAVE INC.
! Email:  info@markimicrowave.com  Phone:  408-778-4200
! Model Number:  FB-2250  Date:  07/13
! Filename:		FB-2250.S2P  Version: 1.0
! Description:  2-port S-parameter data for Band Pass Filter FB-2250
! Frequency Measured: 	10 MHz to 45 GHz
! Measurements:		S11, S21, S12, S22
# Hz S  RI  R 50
! Worked out from all points (two-port):
!   721 points, 10 MHz to 45 GHz, reference 50 ohm
!   highest |S21| = 46.00 dB at 1.697 GHz (marker M1); lowest = 10.5 dB at 21.01 GHz (marker M2)
!   |S21| within 3 dB of the highest: 12.91 GHz to 15.04 GHz (2.129 GHz wide, 15.2 % of centre); 41.96 GHz to 43.98 GHz (2.016 GHz wide, 4.69 % of centre) (the widest 2 of 31)
!   lowest |S11| = -4.5 dB at 5.821 GHz (marker M3), VSWR 3.92, Z = 19.4 - j34.2 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -7.4 to 45.1 dB; largest |S21 - S12| = 3.6e+02
!   the Smith chart shows 5.759 GHz to 5.946 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  45.0  45.3  44.7  45.0
! 1.697 GHz  42.2  46.0  39.5  42.2
! 5.821 GHz  -4.5  45.4  45.4  -7.4
! 7.508 GHz  34.4  45.8  43.8  34.3
! 15.01 GHz  33.1  43.6  39.0  33.9
! 16.01 GHz  16.0  41.0  41.2  -5.2
! 17.38 GHz  43.0  37.9  37.7  42.9
! 19.01 GHz  39.7  18.7  19.7  40.0
! 20.01 GHz  40.6  44.5  44.5  39.8
! 21.01 GHz  41.3  10.5  8.6  41.5
! 22.51 GHz  42.6  42.2  42.1  44.4
! 23.32 GHz  43.7  13.7  12.9  43.3
! 24.44 GHz  39.6  44.6  44.6  41.5
! 25.63 GHz  42.7  11.5  12.6  43.4
! 26.57 GHz  41.7  44.7  44.7  43.6
! 27.44 GHz  37.6  11.2  10.0  41.0
! 30 GHz  24.9  39.4  39.4  30.0
! 33.07 GHz  44.8  38.3  38.0  44.9
! 36.38 GHz  34.5  43.7  40.8  35.7
! 37.5 GHz  -2.7  39.4  37.3  22.6
! 39.56 GHz  36.8  41.5  36.1  34.3
! 45 GHz  40.8  35.5  35.5  42.8
